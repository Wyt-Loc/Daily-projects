# Keil uVision project OLED.uvprojx, settings and files
target OLED (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: OLED +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\OLED;..\FWLIB\inc;..\HARDWARE\ADC;..\HARDWARE\PWM;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/TIMER/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c
    F:/CreatCar/STM32F407VET6-100P--F4系统板资料/【正点原子】探索者STM32F407开发板/【正点原子】探索者STM32F407开发板资料 资料盘(A盘)/4，程序源码/2，标准例程-库函数版本/实验18 ADC实验/FWLIB/src/: stm32f4xx_adc.c
    F:/CreatCar/STM32F407VET6-100P--F4系统板资料/【正点原子】探索者STM32F407开发板/【正点原子】探索者STM32F407开发板资料 资料盘(A盘)/4，程序源码/2，标准例程-库函数版本/实验9 PWM输出实验/FWLIB/src/: stm32f4xx_tim.c
  group README
    ../: readme.txt
